Properties of the parts of a building model (IFC4)

# File
Description: Magnetbefestigungsset für Mehrkanalaktoren oder Klemmenleisten, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BN990002, Magnetbefestigungsset für Mehrkanalaktoren oder Klemmenleisten
In: Raum
Description: Magnetbefestigungsset zur einfachen und sicheren Befestigung der Mehrkanalaktoren oder Klemmenleisten; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BN990002; ModelLabel: JZ-24; GlobalTradeItemNumber: 4050528015679; ProductURL: https://alre.de/produkt_BN990002
Pset_Specification - NominalLength: 0.016 m; NominalWidth: 0.016 m; NominalDepth: 0.0115 m; NetWeight: 0.03
Pset_ALRE_ETIM_Properties - Ausführung: Montagehilfe; Länge: 16; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BN990002.pdf
